# Keil uVision project main.uvprojx, settings and files
target main (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: trh +hex
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\Code;.\Core;.\Devices;.\Periph;.\STLibrary\inc;.\Qmath
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Code
    ./Code/: main.c stm32f10x_it.c system_stm32f10x.c
  group Core
    ./Core/: core_cm3.c startup_stm32f10x_hd.s
  group STLibrary
    ./STLibrary/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Periph
    ./Periph/: dbg.c delay.c flash_rom.c i2c.c systime.c uart.c
  group Devices
    ./Devices/: dht11.c key.c led.c at24c02.c
  group Qmath
    ./Qmath/: Qmath.c
